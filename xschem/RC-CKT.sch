** sch_path: xschem/RC-CKT.sch
**.subckt RC-CKT in ref out
*.ipin in
*.iopin ref
*.opin out
R1 in out 1k m=1
C1 out ref 1p m=1
**.ends
.end
